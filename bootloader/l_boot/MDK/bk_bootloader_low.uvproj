# Keil uVision project bk_bootloader_low.uvproj, settings and files
target target (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: ARM9E-S (Little Endian) ARM
  cpu: CLOCK(60000000) CPUTYPE(ARM9E)
  output: bk_bootloader_low
  AfterMake: fromelf  #L --bin --output bk_bootloader_low.bin
  AfterMake: generate.bat
  c flags: Optim=3 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c misc: --c99
  c include: ..\system;..\drivers
  memory RVCT1: ROM 0x0 size 0x40000
  memory RVCT6: RAM 0x400000 size 0x8000
  scatter file: .\lnk\BK7211.sct
  link misc: --entry 0x00000
  group asm
    ../system/asm/: boot_handlers.s boot_vectors.s
    ./lnk/: BK7211.sct
  group app
    ../applications/: main.c uart_dl.c bootx.c
  group driver
    ../drivers/: driver_flash.c driver_gpio.c driver_icu.c driver_uart0.c driver_uart1.c driver_uart2.c board.c drv_uart.c drv_pwm.c drv_timer.c wdt.c bk_timer.c driver_sys_ctrl.c
  group system
    ../system/: BK_System.c interrupt.c
